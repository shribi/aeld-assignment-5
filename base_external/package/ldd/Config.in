## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd"
	help
	    Includes the kernal modules of ldd3.
```
